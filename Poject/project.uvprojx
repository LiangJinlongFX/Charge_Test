# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\BSP_USER\LED;..\CORE;..\Common;..\STM32f4_LIB\inc;..\SYSTEM;..\BSP_USER\SDIO_SD;..\FATFS\exfuns;..\FATFS\src;..\BSP_USER\MCP3421;..\BSP_USER\IIC;..\BSP_USER\DAC;..\BSP_USER\CSV_Database;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP;.\RTE\RTOS;.\RTE;..\BSP_USER\RTC;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*) --keep *.o(FSymTab)
  group CORE
    ../CORE/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP_USER
    ../BSP_USER/LED/: led.c
    ../BSP_USER/SDIO_SD/: sdio_sdcard.c
    ../BSP_USER/MCP3421/: mcp3421.c
    ../BSP_USER/IIC/: myiic.c
    ../BSP_USER/DAC/: dac.c
    ../BSP_USER/CSV_Database/: CSV_Database.c
    ../BSP_USER/RTC/: rtc.c
  group Common
    ../Common/: delay.c sys.c usart1.c usart2.c
  group STM32F4_LIB
    ../STM32f4_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_dac.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group FATFS
    ../FATFS/exfuns/: exfuns.c
    ../FATFS/src/: diskio.c ff.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_Device
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usb_app.c
software components: CMSIS:CORE 4.3.0, RTOS:device drivers 2.1.2, RTOS:kernel 2.1.2, RTOS:shell 2.1.2
